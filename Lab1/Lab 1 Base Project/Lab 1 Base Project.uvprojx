# Keil uVision project Lab 1 Base Project.uvprojx, settings and files
target Lab1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab 1 Base Project
  c flags: Optim=1 wLevel=2
  c define: HSE_VALUE=8000000 USE_STDPERIPH_DRIVER  ARM_MATH_CM4 __FPU_PRESENT = 1
  c misc: --c99
  c include: .\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User Source Files
    ./source/: fputc_debug.c main.c stm32f4xx.h stm32f4xx_conf.h utils.c utils.h viterbi.c viterbi.h
software components: CMSIS:CORE 4.2.0, CMSIS:DSP 1.4.6, Device:Startup 1.3.1
